Commit message: hw4

File: src/demo133/urdf/fourDOF_h4p6.urdf (robot description, URDF)
Before this commit: robot FourDOF, 18 links, 17 joints
Joints:
- joint theta4: type continuous -> fixed
